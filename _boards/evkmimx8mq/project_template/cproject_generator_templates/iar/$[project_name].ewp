# IAR project $[project_name].ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8MQ6_M4 NXP MIMX8MQ6_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../..; ../../../../../devices/MIMX8MQ6/drivers; ../../../../../devices/MIMX8MQ6; ../../../../../devices/MIMX8MQ6/utilities/io; ../../../../../devices/MIMX8MQ6/utilities/str; ../../../../../devices/MIMX8MQ6/utilities/log; ../../../../../devices/MIMX8MQ6/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: $[project_name].out
  ILINK.IlinkIcfFile: MIMX8MQ6xxxJZ_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMX8MQ6DVAJZ
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MQ6xxxJZ_cm4_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration ddr_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMX8MQ6DVAJZ
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8MQ6xxxJZ_cm4_ddr_ram.icf
  group board
    ../: fsl_iomuxc.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMX8MQ6/drivers/: fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_rdc.h fsl_rdc.c fsl_uart.h fsl_uart.c
  group utilities
    ../../../../../devices/MIMX8MQ6/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMX8MQ6/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMX8MQ6/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMX8MQ6/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_assert.c
  group startup
    ../../../../../devices/MIMX8MQ6/: system_MIMX8MQ6_cm4.c system_MIMX8MQ6_cm4.h
    ../../../../../devices/MIMX8MQ6/iar/: startup_MIMX8MQ6_cm4.s
